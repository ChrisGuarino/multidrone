Commit message: Have a platform for a hovering study

File: assets/stage.urdf (robot description, URDF)
Before this commit: robot maze, 1 links, 0 joints
Links:
- link maze_link: geometry collision mesh filename=platform.stl scale=1.5 1.5 .5; visual mesh filename=platform.stl scale=1.5 1.5 .5
